# IAR project ipwt-05-Radio.ewp, settings and files
configuration Debug (MSP430, debug)
  General.OGChipSelectMenu: CC430F5137 CC430F5137
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: Y:\Programs\Service\MSP430; Y:\Programs\Service\ARM\LPC
  ICC430.CCOptLevel: 0
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnkCC430F5137.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  group main
    ./: define.h exch_main.c global_declaration.h global_var.c hal_pmm.c ini.c interrupts.c main.c RF1A.c RF_Toggle_LED_Demo.c
