<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\ipwt-05-Radio.ewp</path>
  </project>
  <batchBuild/>
</workspace>


